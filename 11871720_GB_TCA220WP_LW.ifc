Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c04a2ed5-7014-418b-9f31-6e9539ed1143, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-19T08:52:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11871720_GB_TCA220WP_LW:12CA2202_GB_11871720_TCA220WP_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, <Unnamed>, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 640 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 12CA2202_GB_11871720_TCA220WP_LW; sets with these values: 2

# IfcDistributionPort, Port_360237_1
Description: Flow; FlowDirection: SOURCEANDSINK
